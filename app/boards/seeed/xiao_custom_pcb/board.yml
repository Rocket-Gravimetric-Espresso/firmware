## app/boards/seeed/xiao_custom_pcb/board.yml
```yaml
board:
  name: xiao_custom_pcb
  vendor: seeed
  socs:
  - name: nrf52840
    variants:
    - name: 'sense'
```
